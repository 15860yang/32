# Keil uVision project NRF24L01发送.uvproj, settings and files
target NRF24L01发送 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: NRF24L01发送 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\NRF2401;.\Usart;.\LCD1602;.\XPT2406
  group User
    ./: NRF24L01发送.c
  group NRF24L01
    ./NRF2401/: NRF24L01.c
  group Usart
    ./Usart/: Usart_Config.c
  group XPT2406
    ./XPT2406/: XPT2046.c
